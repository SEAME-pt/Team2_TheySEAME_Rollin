LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""
